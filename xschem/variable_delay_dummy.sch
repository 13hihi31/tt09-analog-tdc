v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {devices/iopin.sym} 70 -80 0 0 {name=p1 lab=VDD}
C {devices/ipin.sym} 90 -160 0 0 {name=p3 lab=in}
C {devices/opin.sym} 70 -120 0 0 {name=p5 lab=out}
C {devices/iopin.sym} 70 -40 0 0 {name=p2 lab=VSS}
C {variable_delay_unit.sym} 390 -440 0 0 {name=x1}
C {devices/lab_pin.sym} 540 -430 0 1 {name=p10 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 540 -410 0 1 {name=p4 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 540 -450 0 1 {name=p7 sig_type=std_logic lab=out}
C {devices/lab_pin.sym} 240 -470 0 0 {name=p8 sig_type=std_logic lab=in}
C {devices/lab_pin.sym} 540 -470 0 1 {name=p16 sig_type=std_logic lab=forward_0}
C {devices/lab_pin.sym} 240 -430 0 0 {name=p18 sig_type=std_logic lab=out_1}
C {variable_delay_unit.sym} 390 -320 0 0 {name=x9}
C {devices/lab_pin.sym} 540 -310 0 1 {name=p68 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 540 -290 0 1 {name=p69 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 540 -330 0 1 {name=p71 sig_type=std_logic lab=out_1}
C {devices/lab_pin.sym} 240 -350 0 0 {name=p72 sig_type=std_logic lab=forward_0}
C {devices/lab_pin.sym} 240 -330 0 0 {name=p70 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 240 -310 0 0 {name=p75 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 240 -450 0 0 {name=p6 sig_type=std_logic lab=VDD}
