v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {sense_amplifier.sym} 400 -280 0 0 {name=x1}
C {saff_bottom_latch.sym} 400 -140 0 0 {name=x2}
C {devices/iopin.sym} 40 -160 0 0 {name=p1 lab=VDD1}
C {devices/ipin.sym} 60 -360 0 0 {name=p3 lab=d}
C {devices/opin.sym} 40 -240 0 0 {name=p6 lab=q}
C {devices/iopin.sym} 40 -120 0 0 {name=p2 lab=VSS1}
C {devices/ipin.sym} 60 -320 0 0 {name=p4 lab=nd}
C {devices/ipin.sym} 60 -280 0 0 {name=p5 lab=clk}
C {devices/opin.sym} 40 -200 0 0 {name=p7 lab=nq}
C {devices/iopin.sym} 40 -80 0 0 {name=p8 lab=VDD2}
C {devices/iopin.sym} 40 -40 0 0 {name=p9 lab=VSS2}
C {devices/lab_pin.sym} 250 -310 0 0 {name=p10 sig_type=std_logic lab=d}
C {devices/lab_pin.sym} 250 -290 0 0 {name=p11 sig_type=std_logic lab=nd}
C {devices/lab_pin.sym} 250 -270 0 0 {name=p12 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} 550 -170 0 1 {name=p13 sig_type=std_logic lab=q}
C {devices/lab_pin.sym} 550 -150 0 1 {name=p14 sig_type=std_logic lab=nq}
C {devices/lab_pin.sym} 550 -270 0 1 {name=p15 sig_type=std_logic lab=VDD1}
C {devices/lab_pin.sym} 550 -250 0 1 {name=p16 sig_type=std_logic lab=VSS1}
C {devices/lab_pin.sym} 550 -110 0 1 {name=p17 sig_type=std_logic lab=VSS2}
C {devices/lab_pin.sym} 550 -130 0 1 {name=p18 sig_type=std_logic lab=VDD2}
C {devices/lab_pin.sym} 550 -310 0 1 {name=p19 sig_type=std_logic lab=out1}
C {devices/lab_pin.sym} 250 -170 0 0 {name=p20 sig_type=std_logic lab=out1}
C {devices/lab_pin.sym} 250 -150 0 0 {name=p21 sig_type=std_logic lab=out1}
C {devices/lab_pin.sym} 250 -130 0 0 {name=p22 sig_type=std_logic lab=out2}
C {devices/lab_pin.sym} 250 -110 0 0 {name=p23 sig_type=std_logic lab=out2}
C {devices/lab_pin.sym} 550 -290 0 1 {name=p24 sig_type=std_logic lab=out2}
