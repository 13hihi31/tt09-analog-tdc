v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {devices/iopin.sym} 50 -80 0 0 {name=p1 lab=VDD}
C {devices/iopin.sym} 50 -40 0 0 {name=p2 lab=VSS}
C {devices/ipin.sym} 70 -480 0 0 {name=p3 lab=start}
C {devices/ipin.sym} 70 -440 0 0 {name=p4 lab=stop}
C {diff_gen.sym} 510 -500 0 0 {name=x3}
C {devices/lab_pin.sym} 660 -470 2 0 {name=p15 sig_type=std_logic lab=VSS
}
C {devices/lab_pin.sym} 660 -490 2 0 {name=p5 sig_type=std_logic lab=VDD
}
C {devices/lab_pin.sym} 360 -530 0 0 {name=p45 sig_type=std_logic lab=start_delay}
C {devices/lab_pin.sym} 360 -510 0 0 {name=p46 sig_type=std_logic lab=start_buff}
C {devices/lab_wire.sym} 360 -390 0 0 {name=p52 sig_type=std_logic lab=stop}
C {devices/lab_wire.sym} 660 -390 0 1 {name=p67 sig_type=std_logic lab=stop_strong}
C {devices/opin.sym} 50 -400 0 0 {name=p68 lab=term_0}
C {devices/opin.sym} 50 -360 0 0 {name=p69 lab=term_1}
C {devices/opin.sym} 50 -320 0 0 {name=p70 lab=term_2}
C {devices/opin.sym} 50 -280 0 0 {name=p71 lab=term_3}
C {devices/opin.sym} 50 -240 0 0 {name=p72 lab=term_4}
C {devices/lab_pin.sym} 660 -510 0 1 {name=p27 sig_type=std_logic lab=start_neg}
C {devices/lab_pin.sym} 660 -530 0 1 {name=p28 sig_type=std_logic lab=start_pos}
C {devices/opin.sym} 50 -200 0 0 {name=p119 lab=term_5}
C {devices/opin.sym} 50 -160 0 0 {name=p120 lab=term_6}
C {devices/opin.sym} 50 -120 0 0 {name=p121 lab=term_7}
C {vernier_delay_line.sym} 510 -180 0 0 {name=x19}
C {devices/lab_pin.sym} 360 -270 0 0 {name=p122 sig_type=std_logic lab=start_pos}
C {devices/lab_pin.sym} 360 -250 0 0 {name=p123 sig_type=std_logic lab=start_neg}
C {devices/lab_pin.sym} 360 -230 2 1 {name=p124 sig_type=std_logic lab=stop_strong
}
C {devices/lab_pin.sym} 660 -110 2 0 {name=p125 sig_type=std_logic lab=VDD
}
C {devices/lab_pin.sym} 660 -90 2 0 {name=p126 sig_type=std_logic lab=VSS
}
C {devices/lab_pin.sym} 660 -270 2 0 {name=p127 sig_type=std_logic lab=term_0
}
C {devices/lab_pin.sym} 660 -250 2 0 {name=p128 sig_type=std_logic lab=term_1
}
C {devices/lab_pin.sym} 660 -230 2 0 {name=p129 sig_type=std_logic lab=term_2
}
C {devices/lab_pin.sym} 660 -210 2 0 {name=p130 sig_type=std_logic lab=term_3
}
C {devices/lab_pin.sym} 660 -190 2 0 {name=p131 sig_type=std_logic lab=term_4
}
C {devices/lab_pin.sym} 660 -170 2 0 {name=p132 sig_type=std_logic lab=term_5
}
C {devices/lab_pin.sym} 660 -150 2 0 {name=p133 sig_type=std_logic lab=term_6
}
C {devices/lab_pin.sym} 660 -130 2 0 {name=p134 sig_type=std_logic lab=term_7
}
C {stop_buffer.sym} 510 -370 0 0 {name=x1}
C {start_buffer.sym} 510 -640 0 0 {name=x2}
C {devices/lab_pin.sym} 660 -370 2 0 {name=p6 sig_type=std_logic lab=VDD
}
C {devices/lab_pin.sym} 660 -350 2 0 {name=p7 sig_type=std_logic lab=VSS
}
C {devices/lab_wire.sym} 360 -670 0 0 {name=p8 sig_type=std_logic lab=start}
C {devices/lab_wire.sym} 660 -670 0 1 {name=p9 sig_type=std_logic lab=start_delay}
C {devices/lab_wire.sym} 660 -650 0 1 {name=p10 sig_type=std_logic lab=start_buff}
C {devices/lab_pin.sym} 660 -630 2 0 {name=p11 sig_type=std_logic lab=VDD
}
C {devices/lab_pin.sym} 660 -610 2 0 {name=p12 sig_type=std_logic lab=VSS
}
